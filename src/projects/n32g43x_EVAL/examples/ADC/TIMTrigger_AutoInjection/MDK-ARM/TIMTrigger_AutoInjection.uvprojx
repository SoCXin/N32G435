# Keil uVision project TIMTrigger_AutoInjection.uvprojx, settings and files
target N32G43x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32G435CB Nationstech
  pack: Nationstech.N32G43x_DFP.0.1.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TIMTrigger_AutoInjection
  AfterMake: fromelf --bin --output=.\bin\TIMTrigger_AutoInjection.bin .\Objects\TIMTrigger_AutoInjection.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G43X, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32g43x_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g43x.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g43x.c
  group FWLB
    ../../../../../../firmware/n32g43x_std_periph_driver/src/: misc.c n32g43x_adc.c n32g43x_dma.c n32g43x_exti.c n32g43x_gpio.c n32g43x_rcc.c n32g43x_tim.c n32g43x_usart.c
  group USER
    ../src/: main.c n32g43x_it.c
  group DOC
    ../: readme.txt
