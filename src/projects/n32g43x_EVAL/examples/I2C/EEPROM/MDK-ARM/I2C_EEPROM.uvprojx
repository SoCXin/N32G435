# Keil uVision project I2C_EEPROM.uvprojx, settings and files
target N32G43x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G435RB Nationstech
  pack: Nationstech.N32G43x_DFP.0.1.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: I2C_EEPROM_Project +hex
  AfterMake: fromelf --bin --output=.\bin\I2C_EEPROM_Project.bin .\Objects\I2C_EEPROM_Project.axf
  AfterMake: fromelf --vhx -d --32x1 .\Objects\I2C_EEPROM_Project.axf --output=.\bin\I2C_EEPROM_Project.dua
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G43X, USE_STDPERIPH_DRIVER,USE_FULL_ASSERT=1
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32g43x_std_periph_driver\inc;..\..\..\..\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g43x.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g43x.c
  group FWLB
    ../../../../../../firmware/n32g43x_std_periph_driver/src/: misc.c n32g43x_dma.c n32g43x_flash.c n32g43x_gpio.c n32g43x_i2c.c n32g43x_rcc.c n32g43x_usart.c
  group USER
    ../src/: main.c n32g43x_it.c i2c_eeprom.c
  group DOC
    ../: readme.txt
  group LOG
    ../../../../bsp/src/: log.c
