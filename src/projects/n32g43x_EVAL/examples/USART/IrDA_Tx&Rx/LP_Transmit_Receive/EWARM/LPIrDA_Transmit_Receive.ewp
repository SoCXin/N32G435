# IAR project LPIrDA_Transmit_Receive.ewp, settings and files
configuration N32G43x (ARM, debug)
  General.OGChipSelectEditMenu: N32G435RB Nations N32G435RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32G43X; _DLIB_FILE_DESCRIPTOR; USE_STDPERIPH_DRIVER; SYSCLK_SRC=SYSCLK_USE_HSE_PLL; SYSCLK_FREQ=8000000
  ICCARM.CCIncludePath2: ../../../../../../../firmware/CMSIS/core; ../../../../../../../firmware/CMSIS/device; ../../../../../../../firmware/n32g43x_std_periph_driver/inc; ../inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IrDA_Transmit_Receive.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CCMSIS
    ../../../../../../../firmware/CMSIS/device/: system_n32g43x.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../../firmware/n32g43x_std_periph_driver/src/: misc.c n32g43x_gpio.c n32g43x_lptim.c n32g43x_rcc.c n32g43x_tim.c n32g43x_usart.c
  group STARTUP
    ../../../../../../../firmware/CMSIS/device/startup/: startup_n32g43x_EWARM.s
  group USER
    ../src/: bsp_Tim_38K.c main.c n32g43x_it.c
