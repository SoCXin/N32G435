# Keil uVision project RtcAutoWakeUp.uvprojx, settings and files
target N32G43x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32G435RB Nationstech
  pack: Nationstech.N32G43x_DFP.0.9.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RtcAutoWakeUp +hex
  AfterMake: fromelf --bin --output=.\bin\RtcAutoWakeUp.bin .\Objects\RtcAutoWakeUp.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G43X, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32g43x_std_periph_driver\inc;..\..\..\..\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g43x.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g43x.c
  group FWLB
    ../../../../../../firmware/n32g43x_std_periph_driver/src/: misc.c n32g43x_adc.c n32g43x_can.c n32g43x_comp.c n32g43x_crc.c n32g43x_dac.c n32g43x_dbg.c n32g43x_dma.c n32g43x_exti.c n32g43x_flash.c n32g43x_gpio.c n32g43x_i2c.c n32g43x_iwdg.c n32g43x_opamp.c n32g43x_pwr.c n32g43x_rcc.c n32g43x_rtc.c n32g43x_spi.c n32g43x_tim.c n32g43x_tsc.c n32g43x_usart.c n32g43x_wwdg.c
  group USER
    ../src/: main.c n32g43x_it.c User_LED_Config.c User_RTC_Config.c User_Sysclock_Config.c User_RTCBKP_Config.c User_Delay_Config.c
  group LOG
    ../../../../bsp/src/: log.c
  group DOC
    ../: readme.txt
