# IAR project TSC.ewp, settings and files
configuration N32G43x (ARM, debug)
  General.OGChipSelectEditMenu: N32G435RB Nations N32G435RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32G43X; USE_STDPERIPH_DRIVER; USE_FULL_ASSERT; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ../inc; ../../../../../../firmware/CMSIS/core; ../../../../../../firmware/n32g43x_std_periph_driver/inc; ../../../../../../firmware/CMSIS/device
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Bsp
    ../src/: bsp_gpio.c bsp_tsc.c bsp_usart.c
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g43x.c
  group DOC
    ../: readme.txt
  group Driver
    ../../../../../../firmware/n32g43x_std_periph_driver/src/: misc.c n32g43x_exti.c n32g43x_flash.c n32g43x_gpio.c n32g43x_pwr.c n32g43x_rcc.c n32g43x_rtc.c n32g43x_tim.c n32g43x_tsc.c n32g43x_usart.c
  group Startup
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g43x_EWARM.s
  group User
    ../src/: delay.c main.c n32g43x_it.c
